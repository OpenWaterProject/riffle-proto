File: riffle-proto-0.1.sch (EAGLE design)
At the start: 15 parts

Commit message: update
Connections:
- net N$46: now also JP10.11
Other:
- moved on the sheet: JP10, JP11, JP12, JP13, JP14, JP8, JP9
